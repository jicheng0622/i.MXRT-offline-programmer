<?xml version="1.0" encoding="ISO-8859-1" standalone="no"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>Nxp_SBFile_OfflineProgrammer</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>Nxp_SBFile_OfflineProgrammer</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>Nxp_SBFile_OfflineProgrammer</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>Nxp_SBFile_OfflineProgrammer</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/Nxp_SBFile_OfflineProgrammer.ewp</path>
  </project>
</workspace>
