# IAR project Nxp_SBFile_OfflineProgrammer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MK64FN1M0VLL12; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS; USBSTACK_RTOS_FREE_RTOS; BL_EMBEDDED_HOST
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; app; app/blsh; app/disk; app/image_program; CMSIS; middleware/amazon-freertos/FreeRTOS/portable; middleware/amazon-freertos/include; middleware/osa; middleware/sdmmc/inc; middleware/sdmmc/port; middleware/usb; middleware/crc; middleware/fatfs/source; middleware/fatfs/source/fsl_sd_disk; middleware/MultiButton; chip; doc; drivers; startup; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Nxp_SBFile_OfflineProgrammer.srec
  ILINK.IlinkOutputFile: Nxp_SBFile_OfflineProgrammer.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MK64FN1M0VLL12; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: board; source; CMSIS; amazon-freertos/FreeRTOS/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; device; doc; drivers; osa; sdmmc/inc; sdmmc/port; src; startup; usb/device/class; usb/device/class/msc; usb/device/include; usb/device/source; usb/device/source/khci; usb/include; utilities
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x100
  group App
    app/: ffconf.h FreeRTOSConfig.h hardware.c hardware.h main.c
  group App/blsh
    app/blsh/: bllibc.c bllibc.h blsh.c blsh.h host_blsh_cmd.c host_blsh_cmd.h host_command.c host_command.h
  group App/Disk_USB
    app/disk/: usb_buf.h usb_config.h usbd_kinetis.c usbd_user_msc.c
  group App/image_program
    app/image_program/: binary_image.c binary_image.h executable_image.c executable_image.h intelhex_image.c intelhex_image.h SB_image.c SB_image.h srecord_image.c srecord_image.h
  group App/Tasks
    app/: blsh_task.c keyscan_task.c led_task.c usbdisk_task.c
  group Board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group Chip
    chip/: fsl_device_registers.h MK64F12.h MK64F12_features.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm4.h mpu_armv7.h mpu_armv8.h
  group Doc
    doc/: readme.txt
  group Drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_sdhc.c fsl_sdhc.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_uart_freertos.c fsl_uart_freertos.h
  group Middleware/amazon-freertos/FreeRTOS
    middleware/amazon-freertos/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/amazon-freertos/FreeRTOS/portable
    middleware/amazon-freertos/FreeRTOS/portable/: fsl_tickless_generic.h fsl_tickless_systick.c heap_4.c port.c portasm.s portmacro.h
  group Middleware/amazon-freertos/Include
    middleware/amazon-freertos/include/: deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group Middleware/crc
    middleware/crc/src/: crc16.c
    middleware/crc/: crc16.h
  group Middleware/FatFs
    middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c integer.h
    middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group Middleware/MultiButton
    middleware/MultiButton/: multi_button.c multi_button.h
  group Middleware/osa
    middleware/osa/: usb_osa.h usb_osa_freertos.c usb_osa_freertos.h
  group Middleware/sdmmc/inc
    middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group Middleware/sdmmc/port
    middleware/sdmmc/port/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group Middleware/sdmmc/src
    middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group Middleware/usb
    middleware/usb/: rl_usb.h usb.h usb_def.h usb_for_lib.h usb_lib.c usb_msc.h usbd_core.c usbd_core.h usbd_core_msc.h usbd_desc.h usbd_event.h usbd_hw.h usbd_lib_msc.h usbd_msc.h
  group Middleware/usb/msc
    middleware/usb/msc/: usbd_core_msc.c usbd_msc.c
  group Startup
    startup/: startup_MK64F12.s system_MK64F12.c system_MK64F12.h
  group Utilities
    utilities/: Retarget_console.c
